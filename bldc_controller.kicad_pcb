# Repository aditelik/bldc_controller

## KiCad design bldc_controller.kicad_pcb

Parts:
C1, C2: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C7, C8, C12, C13, C14, C20, C22, C23, C24, C25, C26, C33, C37: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4, C11: 47uF; CP_Radial_D10.0mm_P5.00mm
C5: 0.33uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 0.22uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9, C15: 22uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C10, C16, C17, C21: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C18, C19: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C27: 10nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C28, C29, C30: 22nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C31: 1nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C32: 100pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C34, C35, C36: 0.47uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D3, D4, D6: LTST-C171GKT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2, D5: LTST-C171KRKT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D8: SMF10A; D_SOD-123F
D9: LTST-C171TBKT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D10, D11: BAT54HT1G; D_SOD-323_HandSoldering
D12: SMF12A; D_SOD-123F
D13: SMF5.0A; D_SOD-123F
D14, D15, D16: 1N5819; D_SOD-123
F1: 5A Fuse; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; Part Number 0685T5000-01
FB1: BL01RN1A1D2B; Ferrite_Bead_TH
J1: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
J2: Screw_Terminal_01x04; Terminal_Block_4Pin_TH
JP1: SolderJumper_2_Open; Solder_Jumper_2_Pin_5A
Q1: 2N7002E; SOT-23
Q2, Q3: DMN65D8L-7; SOT-23
Q4: MMBT3904; SOT-23
Q5: IRF4905; TO-220-3_Vertical
Q6, Q7, Q8, Q9, Q10, Q11: IRLB8721PBF; TO-220-3_Vertical
R1, R3, R9, R16, R20, R46, R47, R48, R49, R50, R51: 1K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R8, R10, R13: 300; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R11, R12, R17, R18, R23, R43, R44, R45: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5: 800; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R7: 220; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14, R31, R33, R35, R37, R39, R41: 10; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R15, R32, R34, R36, R38, R40, R42: 100K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R19: 3K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R21, R24, R25, R29, R30: 1; Power_Resistor_TH
R22: 40K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R26, R27, R28: 4.7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R52, R53: 0; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1: 5K; Trimmer_Pot_SM
SW1: 1301.9314; Tactile_Switch_SM
SW2: D6C50 F1 LFS; Pushbutton_Switch_TH
SW3: D6C40 F1 LFS; Pushbutton_Switch_TH
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP13, TP14, TP15, TP16, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP30: TestPoint; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
TP12, TP17, TP18, TP29: TestPoint; TestPoint_Keystone_5000-5004_Miniature
U1: ATmega328P-PU; DIP-28_W7.62mm
U2: SN74LVC1G11DBVR; SOT-23-6_Handsoldering
U3: uA7810; TO-220-3_Vertical
U4: LM7805_TO220; TO-220-3_Vertical
U5: CD4044BE; DIP-16_W7.62mm
U6: LM339; DIP-14_W7.62mm
U7: MCP601-xP; DIP-8_W7.62mm
U8, U9, U10: IRS2004; DIP-8_W7.62mm
Y1: 9B-16.000MBBK-B; Crystal_16MHz_TH

Connections:
+5V: C7.2, C8.1, C12.1, C14.1, C22.1, C26.1, C33.1, D5.2 (A), D6.2 (A), D9.2 (A), D10.1 (K), D11.1 (K), D13.1 (K), J1.5, Q1.2 (S), R9.1, R11.1, R12.1, R15.1, R16.1, R46.1, R47.1, R48.1, RV1.3, TP27.1, U1.7 (VCC), U1.20 (AVCC), U2.5 (VCC), U4.3 (VO), U5.16 (VDD), U6.3 (V+), U7.7 (V+)
+10V: C6.1, C13.1, C23.2, C24.2, C25.2, D4.2 (A), D8.1 (K), R14.2, R26.2, R27.2, R28.2, TP26.1, U3.3 (OUT), U8.1 (VCC), U9.1 (VCC), U10.1 (VCC)
+12V: C5.1, C11.1, C15.1, C17.1, C20.1, D1.2 (A), D12.1 (K), FB1.1, JP1.1 (A), TP25.1, U3.1 (IN)
+BATT: C4.1, F1.2, J2.1
/ANALOG_IN: J1.4, U1.24 (PC1)
/AUX_IN: R4.1, SW1.1, U1.5 (PD3)
/AUX_OUT: Q3.1 (G), U1.27 (PC4)
/BEMF_A: R46.2, TP13.1, U1.12 (PD6), U6.1
/BEMF_B: R47.2, TP14.1, U1.14 (PB0), U6.14
/BEMF_C: R48.2, TP15.1, U1.13 (PD7), U6.13
/EFUSE_EN: Q2.1 (G), R17.1, R19.2, TP3.1, U5.13 (Q1)
/I_RAW: C27.1, C31.1, C32.1, Q7.3 (S), Q9.3 (S), Q11.3 (S), R21.1, R24.1, R25.1, R29.1, R30.1, TP1.1, U7.3 (+)
/I_SENSE: R22.1, TP30.1, U1.26 (PC3), U6.4 (-), U7.6
/MCU_A_EN: TP19.1, U1.23 (PC0), U8.3 (~SD)
/MCU_A_SIG: TP22.1, U1.17 (PB3), U8.2 (IN)
/MCU_B_EN: TP24.1, U1.19 (PB5), U9.3 (~SD)
/MCU_B_SIG: TP21.1, U1.16 (PB2), U9.2 (IN)
/MCU_C_EN: TP23.1, U1.18 (PB4), U10.3 (~SD)
/MCU_C_SIG: TP20.1, U1.15 (PB1), U10.2 (IN)
/NEUTRAL: R43.1, R44.1, R45.1, TP16.1, U6.6 (-), U6.8 (-), U6.10 (-)
/RXD: J1.2, U1.2 (PD0)
/TXD: J1.3, U1.3 (PD1)
/nESTOP: C2.1, D11.2 (A), R12.2, SW3.2, U2.3 (B)
/nI_ERR: Q1.1 (G), R16.2, TP2.1, U2.1 (A), U6.2
/nMCU_ERR: U1.28 (PC5), U2.6 (C)
/nRESET: C1.1, D10.2 (A), J1.1, R11.2, SW2.1, U1.1 (~RESET~/PC6), U5.3 (S1)
GNDD: C1.2, C2.2, C3.2, C5.2, C6.2, C7.1, C8.2, C12.2, C13.2, C14.2, C16.2, C18.1, C19.2, C22.2, C23.1, C24.1, C25.1, C26.2, C27.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, D2.1 (K), D8.2 (A), D12.2 (A), D13.2 (A), J1.6, Q2.2 (S), Q3.2 (S), Q4.2 (E), R1.2, R3.2, R4.2, R5.2, R6.2, R7.2, R10.2, R17.2, R23.2, R32.2, R34.2, R36.2, R38.2, R40.2, R42.2, R52.2, R53.2, RV1.1, TP12.1, TP17.1, TP29.1, U1.8 (GND), U1.22 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.6 (R2), U5.7 (S2), U5.8 (VSS), U5.11 (S3), U5.12 (R3), U5.14 (R4), U5.15 (S4), U6.12 (V-), U7.4 (V-), U8.4 (COM), U9.4 (COM), U10.4 (COM)
GNDPWR: C4.2, C9.2, C10.2, C11.2, C15.2, C17.2, C20.2, C37.2, J2.3, J2.4, R21.2, R24.2, R25.2, R29.2, R30.2, R52.1, R53.1, TP18.1
unnamed: C3.1, U1.21 (AREF)
unnamed: C16.1, R15.2, U5.5 (ENABLE)
unnamed: C18.2, U1.9 (XTAL1/PB6), Y1.1
unnamed: C19.1, U1.10 (XTAL2/PB7), Y1.2
unnamed: C21.2, Q5.1 (G), R18.2, R20.1, TP5.1
unnamed: C28.1, D14.1 (K), U8.8 (VB)
unnamed: C29.1, D15.1 (K), U9.8 (VB)
unnamed: C30.1, D16.1 (K), U10.8 (VB)
unnamed: D1.1 (K), R1.1
unnamed: D2.2 (A), R2.2
unnamed: D3.1 (K), R3.1
unnamed: D4.1 (K), R5.1
unnamed: D5.1 (K), R8.1
unnamed: D6.1 (K), R10.1
unnamed: D9.1 (K), R13.1
unnamed: D14.2 (A), R26.1
unnamed: D15.2 (A), R27.1
unnamed: D16.2 (A), R28.1
unnamed: F1.1, FB1.2
unnamed: Q1.3 (D), R2.1
unnamed: Q2.3 (D), R8.2
unnamed: Q3.3 (D), R13.2
unnamed: Q4.1 (B), R19.1
unnamed: Q4.3 (C), R20.2
unnamed: Q6.1 (G), R31.1, R32.1, TP9.1
unnamed: Q7.1 (G), R33.1, R34.1
unnamed: Q8.1 (G), R35.1, R36.1, TP10.1
unnamed: Q9.1 (G), R37.1, R38.1
unnamed: Q10.1 (G), R39.1, R40.1, TP11.1
unnamed: Q11.1 (G), R41.1, R42.1
unnamed: R6.1, SW2.2
unnamed: R7.1, SW3.1
unnamed: R9.2, SW1.2
unnamed: R14.1, U4.1 (VI)
unnamed: R22.2, R23.1, U7.2 (-)
unnamed: R31.2, U8.7 (HO)
unnamed: R33.2, U8.5 (LO)
unnamed: R35.2, U9.7 (HO)
unnamed: R37.2, U9.5 (LO)
unnamed: R39.2, U10.7 (HO)
unnamed: R41.2, U10.5 (LO)
unnamed: R49.2, U6.7 (+)
unnamed: R50.2, U6.9 (+)
unnamed: R51.2, U6.11 (+)
unnamed: RV1.2, TP4.1, U6.5 (+)
unnamed: U2.4 (Y), U5.4 (R1)
PhaseA: C28.2, C34.1, Q6.3 (S), Q7.2 (D), R43.2, R49.1, TP6.1, U8.6 (VS)
PhaseB: C29.2, C35.1, Q8.3 (S), Q9.2 (D), R44.2, R50.1, TP7.1, U9.6 (VS)
PhaseC: C30.2, C36.1, Q10.3 (S), Q11.2 (D), R45.2, R51.1, TP8.1, U10.6 (VS)
VBUS: D3.2 (A), Q5.2 (D), Q6.2 (D), Q8.2 (D), Q10.2 (D)
Vdrive: C9.1, C10.1, C21.1, C37.1, J2.2, JP1.2 (B), Q5.3 (S), R18.1, TP28.1

Notes on the sheet:
ESTOP
OVERCURRENT
Latching Circuit
Voltage Generation & Protection
Input Connections
Microcontroller
Back EMF Sensing Crossover Detection
Half-Bridge Drivers
RESET
POWER

Board: 4 copper layers, 99.1 x 99.1 mm, 166 parts (62 on the bottom side), 79 nets.

File AutoBOM.xlsx:

ref | value5 | footprint | part | description | Min Quantity | Status
C1 | 10uF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C_Small | Unpolarized capacitor, small symbol | 2 | None
C10 | 1uF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C | Unpolarized capacitor | 4 | None
C11 | 47uF | Capacitor_THT:CP_Radial_D10.0mm_P5.00mm | CP | Polarized capacitor |  | Plenty
C12 | 0.1uF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C_Small | Unpolarized capacitor, small symbol | 14 | None
C15 | 22uF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C | Unpolarized capacitor | 2 | None
C18 | 22pF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C_Small | Unpolarized capacitor, small symbol | 2 | None
C27 | 10nF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C_Small | Unpolarized capacitor, small symbol | 1 | None
C28 | 22nF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C | Unpolarized capacitor | 3 | None
C31 | 1nF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C_Small | Unpolarized capacitor, small symbol | 1 | None
C32 | 100pF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C_Small | Unpolarized capacitor, small symbol | 1 | None
C34 | 0.47uF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C | Unpolarized capacitor | 3 | None
C5 | 0.33uF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C | Unpolarized capacitor | 1 | None
C6 | 0.22uF | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | C | Unpolarized capacitor | 1 | None
D10 | BAT54HT1G | Diode_SMD:D_SOD-323_HandSoldering | 1N914 | 100V 0.3A Small Signal Fast Switching Diode, DO-35 | 2 | None
D12 | SMF12A | Diode_SMD:D_SOD-123F | D_Zener | Zener diode | 1 | None
D13 | SMF5.0A | Diode_SMD:D_SOD-123F | D_Zener | Zener diode | 1 | None
D14 | 1N5819 | Diode_SMD:D_SOD-123 | 1N5818 | 30V 1A Schottky Barrier Rectifier Diode, DO-41 | 3 | None
D2 | LTST-C171KRKT | LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder | Green LED | Light emitting diode | 5 | None
D3 | LTST-C171GKT | LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder | Red LED | Light emitting diode | 1 | None
D4 | LTST-C171GKT | LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder | Blue LED | Light emitting diode | 1 | None
D8 | SMF10A | Diode_SMD:D_SOD-123F | D_Zener | Zener diode | 1 | None
F1 | 5A Fuse | Fuse:Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder | Fuse | Fuse | 1 | None
FB1 | BL01RN1A1D2B | Ferrite_THT:Ferrite_Bead_TH | Ferrite_Bead | Ferrite bead | 1 | None
J1 | Conn_01x06_Male | Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical | Conn_01x06_Male | Generic connector, single row, 01x06, script generated (kicad-library-utils/sch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 | 1 | None
J2 | Screw_Terminal_01x04 | Connector:Terminal_Block_4Pin_TH | Screw_Terminal_01x04 | Generic screw terminal, single row, 01x04, script generated (kicad-library-util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 | 1 | None
Q1 |  | Package_TO_SOT_SMD:SOT-23 |  | P-Channel MOSFET, SOT-23 | 1 | None
Q10 | IRLB8721PBF | Package_TO_SOT_THT:TO-220-3_Vertical | IRLB8721PBF | 62A Id, 30V Vds, N-Channel MOSFET, TO-220 | 1 | Some
Q3 | DMN65D8L-7 | Package_TO_SOT_SMD:SOT-23 | DMN67D7L | 0.21A Id, 60V Vds, N-Channel MOSFET, SOT-23 | 2 | None
Q4 | MMBT3904 | Package_TO_SOT_SMD:SOT-23 | MMBT3904 | 0.2A Ic, 40V Vce, Small Signal NPN Transistor, SOT-23 | 1 | None
Q5 | IRF4905 | Package_TO_SOT_THT:TO-220-3_Vertical | IRF4905 | -74A Id, -55V Vds, Single P-Channel HEXFET Power MOSFET, 20mOhm Ron, TO-220AB | 1 | Some
R1 | 1K | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 11 | None
R11 | 10K | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 9 | None
R14 | 10 | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 7 | None
R15 | 100K | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 7 | None
R19 | 3K | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 1 | None
R21 | 1 | Resistor_THT:Power_Resistor_TH | R_US | Resistor, US symbol | 5 | Some
R22 | 40K | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 1 | None
R28 | 4.7 | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 3 | None
R5 | 800 | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 1 | None
R7 | 220 | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 2 | None
U6 | LM339 | Package_DIP:DIP-14_W7.62mm | LM339 | Quad Differential Comparators, DIP-14/SOIC-14/SSOP-14 |  | Plenty
R8 | 300 | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | R_US | Resistor, US symbol | 4 | None
RV1 | 5K | Potentiometer_SMD:Trimmer_Pot_SM | R_POT | Potentiometer | 1 | None
SW1 | 1301.9314 | Button_Switch_SMD:Tactile_Switch_SM | SW_Push | Push button switch, generic, two pins | 1 | None
SW2 | D6C50 F1 LFS | Button_Switch_THT:Pushbutton_Switch_TH | SW_Push | Push button switch, generic, two pins | 1 | None
SW3 | D6C40 F1 LFS | Button_Switch_THT:Pushbutton_Switch_TH | SW_Push | Push button switch, generic, two pins | 1 | None
TP29 | TestPoint | TestPoint:TestPoint_Keystone_5000-5004_Miniature | TestPoint | test point | 4 | None
U1 | ATmega328P-PU | Package_DIP:DIP-28_W7.62mm | ATmega328P-PU | 20MHz, 32kB Flash, 2kB SRAM, 1kB EEPROM, DIP-28 | 1 | Some
U10 | IRS2004 | Package_DIP:DIP-8_W7.62mm | IRS2004 | Half-Bridge Driver, 200V, 290/600mA, PDIP-8/SOIC-8 | 2 | Some
U2 | SN74LVC1G11DBVR | Package_TO_SOT_SMD:SOT-23-6_Handsoldering | SN74LVC1G11DBVR |  | 3 | None
U3 | uA7810 | Package_TO_SOT_THT:TO-220-3_Vertical | uA7810 | Positive 1A 35V Linear Regulator, Fixed Output 10V, TO-220/TO-263 | 1 | Some
U4 | LM7805_TO220 | Package_TO_SOT_THT:TO-220-3_Vertical | LM7805_TO220 | Positive 1A 35V Linear Regulator, Fixed Output 5V, TO-220 | 1 | Some
U5 | CD4044BE | Package_DIP:DIP-16_W7.62mm | CD4044BE |  | 3 | None
U7 | MCP601-xP | Package_DIP:DIP-8_W7.62mm | MCP601-xP | Single 2.7V to 6.0V Single Supply CMOS Op Amps, DIP-8 | 3 | None
Y1 | 9B-16.000MBBK-B | Crystal:Crystal_16MHz_TH | Crystal | Two pin crystal | 1 | Some

## Commit log

2019-11-04 Update Filenames
2019-11-04 Update Schematic
2019-11-04 Remove Project File
2019-11-04 Add Half Bridge Sim Files
2019-11-04 adding power simulations
2019-11-04 Fix pMOSFET on Power Sim
2019-11-18 Update Half Bridge Sim
2019-11-18 Basically Ready for Layout
2019-11-18 Ready for Layout
2019-11-18 Ready to Route
2019-11-18 Done with First Pass of Layout
2019-11-18 Forgot a Connection
2019-11-18 added vias for motor
2019-11-19 finished labelling
2019-11-19 fixed small bug
2019-11-19 fixed wire thickness
2019-11-22 Manual Revert
2019-11-22 Added some shapes
2019-11-22 Finished Ground Planes
2019-11-22 Almost Done with Layout V2
2019-11-22 Just Need to Fix Silkscreen
2019-11-22 Just Need to Fix Bottom Silkscreen
2019-11-22 V2 Ready for Fab
2019-11-22 Need to check if output vias are plated
2019-11-23 Ready for Fab Actually
2019-11-23 Added Preliminary BOMs
2019-11-23 Fixed PMOS footprint
2019-11-25 Files that were Sent for Fab
2019-11-26 Added Final Digikey BOM
2019-11-26 cleaned up schematic
